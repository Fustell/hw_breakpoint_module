FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://my-kallsyms.cfg"